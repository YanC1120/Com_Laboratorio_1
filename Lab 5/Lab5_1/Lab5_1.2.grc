options:
  parameters:
    author: Grupo01J1A
    category: '[Grupo01]'
    copyright: Grupo01J1A
    generate_options: qt_gui
    id: Lab5
    output_language: python
    title: Compara
  states: {}

blocks:
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frec muestreo
    start: '0'
    step: '100'
    stop: 2000e3
    value: 100e3
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frec señal cuadrada
    start: '0'
    step: '100'
    stop: 50e3
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: Ancho de pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: ModuladorPAM_0
  id: ModuladorPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {state: disabled}
- name: ModuladorPAM_0_0
  id: ModuladorPAM
  parameters:
    d: w
    fs: fs
    samp_rate: fm
  states: {state: disabled}
- name: ModuladorPAM_0_0_0
  id: ModuladorPAM
  parameters:
    d: w
    fs: fs
    samp_rate: fm
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: fm
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: fm
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: A
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style1: '4'
    type: float
    update_time: '0.1'
  states: {}

connections:
- [ModuladorPAM_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorPAM_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0, '0', ModuladorPAM_0, '0']
- [analog_sig_source_x_1, '0', ModuladorPAM_0_0_0, '0']
- [analog_sig_source_x_1, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_2, '0', ModuladorPAM_0_0, '0']

metadata:
  file_format: 1
