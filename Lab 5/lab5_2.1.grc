options:
  parameters:
    author: J1A_G5
    generate_options: qt_gui
    id: Compara
    output_language: python
    title: Compara
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud
    start: '0'
    step: '0.01'
    stop: '2'
    value: '2'
  states: {}
- name: AM
  id: variable_qtgui_range
  parameters:
    label: Am
    start: '-2'
    step: '0.01'
    stop: '2'
    value: '0'
  states: {}
- name: Of
  id: variable_qtgui_range
  parameters:
    label: Offest
    start: '-2'
    step: '0.01'
    stop: '2'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: ModulosEfren_Compara_0
  id: ModulosEfren_Compara
  parameters: {}
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: AM
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: 2*A
    freq: '10000'
    offset: '-A+Of'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '10240'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModulosEfren_Compara_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0, '0', ModulosEfren_Compara_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', ModulosEfren_Compara_0, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
